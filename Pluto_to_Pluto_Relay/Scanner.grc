options:
  parameters:
    author: sact
    generate_options: qt_gui
    id: Scanner
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: attenuation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '433000000'
  states: {}
- name: center_freq_0
  id: variable
  parameters:
    value: '868000000'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '2'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '11'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import paho.mqtt.client as mqtt
      import threading
      import queue


      class mqtt_publisher(gr.sync_block):
          """
          MQTT Publisher Block (Local Broker)
          - Nhận byte stream từ GNU Radio
          - Gom thành chuỗi (theo '\n') và publish lên MQTT
          """

          def __init__(self, host="127.0.0.1", port=1883,
                       username=None, password=None,
                       topic="gnuradio/output"):
              gr.sync_block.__init__(
                  self,
                  name="MQTT Publisher",
                  in_sig=[np.uint8],
                  out_sig=None
              )

              self.host = host
              self.port = port
              self.username = username
              self.password = password
              self.topic = topic

              self.buffer = bytearray()

              # MQTT client
              self.client = mqtt.Client()
              if self.username and self.password:
                  self.client.username_pw_set(self.username, self.password)

              self.client.on_connect = self.on_connect

              # Thread MQTT
              self.mqtt_thread = threading.Thread(target=self._mqtt_loop, daemon=True)
              self.mqtt_thread.start()

          def on_connect(self, client, userdata, flags, rc):
              if rc == 0:
                  print("[MQTT] Publisher connected to local broker")
              else:
                  print("[MQTT] Publisher failed, rc=", rc)

          def _mqtt_loop(self):
              self.client.connect(self.host, self.port, keepalive=60)
              self.client.loop_forever()

          def work(self, input_items, output_items):
              data = input_items[0]
              
              if len(data) > 0:
                  msg = bytes(data).decode("utf-8", errors="ignore")
                  if msg.strip():
                      self.client.publish(self.topic, msg)
                      print(f"[MQTT] Published: {msg}")

              return len(data)
    host: '''127.0.0.1'''
    password: '''1'''
    port: '1883'
    topic: '''data/output'''
    username: '''root'''
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import paho.mqtt.client as mqtt
      import threading
      import queue


      class mqtt_publisher(gr.sync_block):
          """
          MQTT Publisher Block (Local Broker)
          - Nhận byte stream từ GNU Radio
          - Gom thành chuỗi (theo '\n') và publish lên MQTT
          """

          def __init__(self, host="127.0.0.1", port=1883,
                       username=None, password=None,
                       topic="gnuradio/output"):
              gr.sync_block.__init__(
                  self,
                  name="MQTT Publisher",
                  in_sig=[np.uint8],
                  out_sig=None
              )

              self.host = host
              self.port = port
              self.username = username
              self.password = password
              self.topic = topic

              self.buffer = bytearray()

              # MQTT client
              self.client = mqtt.Client()
              if self.username and self.password:
                  self.client.username_pw_set(self.username, self.password)

              self.client.on_connect = self.on_connect

              # Thread MQTT
              self.mqtt_thread = threading.Thread(target=self._mqtt_loop, daemon=True)
              self.mqtt_thread.start()

          def on_connect(self, client, userdata, flags, rc):
              if rc == 0:
                  print("[MQTT] Publisher connected to local broker")
              else:
                  print("[MQTT] Publisher failed, rc=", rc)

          def _mqtt_loop(self):
              self.client.connect(self.host, self.port, keepalive=60)
              self.client.loop_forever()

          def work(self, input_items, output_items):
              data = input_items[0]
              
              if len(data) > 0:
                  msg = bytes(data).decode("utf-8", errors="ignore")
                  if msg.strip():
                      self.client.publish(self.topic, msg)
                      print(f"[MQTT] Published: {msg}")

              return len(data)
    host: '''127.0.0.1'''
    password: '''1'''
    port: '1883'
    topic: '''data/rssi'''
    username: '''root'''
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import paho.mqtt.client as mqtt
      import threading
      import queue


      class mqtt_publisher(gr.sync_block):
          """
          MQTT Publisher Block (Local Broker)
          - Nhận byte stream từ GNU Radio
          - Gom thành chuỗi (theo '\n') và publish lên MQTT
          """

          def __init__(self, host="127.0.0.1", port=1883,
                       username=None, password=None,
                       topic="gnuradio/output"):
              gr.sync_block.__init__(
                  self,
                  name="MQTT Publisher",
                  in_sig=[np.uint8],
                  out_sig=None
              )

              self.host = host
              self.port = port
              self.username = username
              self.password = password
              self.topic = topic

              self.buffer = bytearray()

              # MQTT client
              self.client = mqtt.Client()
              if self.username and self.password:
                  self.client.username_pw_set(self.username, self.password)

              self.client.on_connect = self.on_connect

              # Thread MQTT
              self.mqtt_thread = threading.Thread(target=self._mqtt_loop, daemon=True)
              self.mqtt_thread.start()

          def on_connect(self, client, userdata, flags, rc):
              if rc == 0:
                  print("[MQTT] Publisher connected to local broker")
              else:
                  print("[MQTT] Publisher failed, rc=", rc)

          def _mqtt_loop(self):
              self.client.connect(self.host, self.port, keepalive=60)
              self.client.loop_forever()

          def work(self, input_items, output_items):
              data = input_items[0]
              
              if len(data) > 0:
                  msg = bytes(data).decode("utf-8", errors="ignore")
                  if msg.strip():
                      self.client.publish(self.topic, msg)
                      print(f"[MQTT] Published: {msg}")

              return len(data)
    host: '''127.0.0.1'''
    password: '''1'''
    port: '1883'
    topic: '''data/hardwaregain'''
    username: '''root'''
  states: {}
- name: epy_block_0_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import paho.mqtt.client as mqtt
      import threading
      import queue


      class mqtt_publisher(gr.sync_block):
          """
          MQTT Publisher Block (Local Broker)
          - Nhận byte stream từ GNU Radio
          - Gom thành chuỗi (theo '\n') và publish lên MQTT
          """

          def __init__(self, host="127.0.0.1", port=1883,
                       username=None, password=None,
                       topic="gnuradio/output"):
              gr.sync_block.__init__(
                  self,
                  name="MQTT Publisher",
                  in_sig=[np.uint8],
                  out_sig=None
              )

              self.host = host
              self.port = port
              self.username = username
              self.password = password
              self.topic = topic

              self.buffer = bytearray()

              # MQTT client
              self.client = mqtt.Client()
              if self.username and self.password:
                  self.client.username_pw_set(self.username, self.password)

              self.client.on_connect = self.on_connect

              # Thread MQTT
              self.mqtt_thread = threading.Thread(target=self._mqtt_loop, daemon=True)
              self.mqtt_thread.start()

          def on_connect(self, client, userdata, flags, rc):
              if rc == 0:
                  print("[MQTT] Publisher connected to local broker")
              else:
                  print("[MQTT] Publisher failed, rc=", rc)

          def _mqtt_loop(self):
              self.client.connect(self.host, self.port, keepalive=60)
              self.client.loop_forever()

          def work(self, input_items, output_items):
              data = input_items[0]
              
              if len(data) > 0:
                  msg = bytes(data).decode("utf-8", errors="ignore")
                  if msg.strip():
                      self.client.publish(self.topic, msg)
                      print(f"[MQTT] Published: {msg}")

              return len(data)
    host: '''127.0.0.1'''
    password: '''1'''
    port: '1883'
    topic: '''data/hex'''
    username: '''root'''
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import paho.mqtt.client as mqtt
      import threading
      import queue

      class mqtt_subscriber(gr.sync_block):
          """
          MQTT Subscriber Block (Local Broker)
          - Nhận message từ Node-RED hoặc client MQTT khác
          - Segment payload thành subpayload (<= max_len, thêm '\n')
          - Xuất ra stream GNU Radio (byte)
          """

          def __init__(self, host="127.0.0.1", port=1883,
                       username=None, password=None,
                       topic="gnuradio/input", buf_len=1024, max_len=255):
              gr.sync_block.__init__(
                  self,
                  name="MQTT Subscriber",
                  in_sig=None,
                  out_sig=[np.uint8]
              )

              self.host = host
              self.port = port
              self.username = username
              self.password = password
              self.topic = topic
              self.buf_len = buf_len
              self.max_len = max_len

              self.queue = queue.Queue()

              # MQTT client
              self.client = mqtt.Client()
              if self.username and self.password:
                  self.client.username_pw_set(self.username, self.password)

              self.client.on_connect = self.on_connect
              self.client.on_message = self.on_message

              # Thread MQTT
              self.mqtt_thread = threading.Thread(target=self._mqtt_loop, daemon=True)
              self.mqtt_thread.start()

          def on_connect(self, client, userdata, flags, rc):
              if rc == 0:
                  print("[MQTT] Connected to local broker")
                  client.subscribe(self.topic)
              else:
                  print("[MQTT] Failed to connect, rc=", rc)

          def on_message(self, client, userdata, msg):
              text = msg.payload.decode("utf-8")
              print(f"[MQTT] Received: {text}")

              # Segmenter
              data = text.encode("utf-8")
              for i in range(0, len(data), self.max_len):
                  sub = data[i:i + self.max_len]
                  if len(sub) < 2:
                      sub = sub + b' '
                  sub = sub + b'\n'
                  arr = np.frombuffer(sub, dtype=np.uint8)
                  for b in arr:
                      self.queue.put(b)

          def _mqtt_loop(self):
              self.client.connect(self.host, self.port, keepalive=60)
              self.client.loop_forever()

          def work(self, input_items, output_items):
              out = output_items[0]

              i = 0
              while not self.queue.empty() and i < len(out):
                  out[i] = self.queue.get()
                  i += 1

              return i
    buf_len: '1024'
    host: '''127.0.0.1'''
    max_len: '255'
    password: '''1'''
    port: '1883'
    topic: '''data/input'''
    username: '''root'''
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import adi
      import time

      class pluto_rssi_stream_source(gr.sync_block):
          """
          GRC Block: Đọc RSSI từ Pluto và xuất ra dưới dạng Byte Stream (cổng tím).
          
          PHIÊN BẢN SỬA ĐỔI: Khối này tạo ra một luồng byte thay vì message.
          Đây là cách làm phức tạp hơn và ít được khuyến khích.
          """
          def __init__(self, sdr_uri='ip:192.168.2.1', update_interval=1.0):
              gr.sync_block.__init__(
                  self,
                  name='Pluto RSSI Source',
                  in_sig=[],
                  # ĐỊNH NGHĨA ĐẦU RA LÀ BYTE STREAM (màu tím)
                  out_sig=[np.byte] 
              )

              self.sdr_uri = sdr_uri
              self.update_interval = update_interval
              self.last_update_time = 0
              
              # Bộ đệm (buffer) nội bộ để chứa các byte đang chờ được gửi đi
              self.pending_bytes = bytearray()

          def work(self, input_items, output_items):
              out_buffer = output_items[0]
              n_out = len(out_buffer) # Số byte có thể ghi ra ở lần gọi này
              
              current_time = time.time()
              
              # 1. Kiểm tra xem đã đến lúc đọc giá trị mới từ SDR chưa
              if (current_time - self.last_update_time) > self.update_interval:
                  self.last_update_time = current_time
                  
                  try:
                      sdr = adi.Pluto(self.sdr_uri)
                      rssi_raw = sdr._ctrl.find_channel('voltage0').attrs['rssi'].value
                      rssi_str = str(int(float(rssi_raw.split()[0])))
                      
                      # Thêm dữ liệu mới (đã mã hóa) vào bộ đệm đang chờ
                      self.pending_bytes.extend(rssi_str.encode('utf-8'))
                      del sdr
                  except Exception as e:
                      print(f"[Pluto RSSI Stream] Lỗi: {e}")

              # 2. Kiểm tra xem có byte nào đang chờ trong bộ đệm không
              if len(self.pending_bytes) > 0:
                  # Xác định số byte sẽ được ghi ra lần này
                  # (không thể nhiều hơn dung lượng của out_buffer)
                  num_to_write = min(n_out, len(self.pending_bytes))
                  
                  # Sao chép byte từ bộ đệm đang chờ sang bộ đệm đầu ra
                  out_buffer[:num_to_write] = self.pending_bytes[:num_to_write]
                  
                  # Xóa các byte đã được ghi khỏi bộ đệm đang chờ
                  self.pending_bytes = self.pending_bytes[num_to_write:]
                  
                  # Trả về số byte đã thực sự ghi ra
                  return num_to_write
              else:
                  # Nếu không có gì để ghi, trả về 0
                  return 0
    sdr_uri: '''ip:192.168.2.1'''
    update_interval: '1.0'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import adi
      import time

      class pluto_gain_stream_source(gr.sync_block):
          """
          GRC Block: Đọc Hardware Gain từ Pluto và xuất ra dưới dạng Byte Stream (cổng tím).

          PHIÊN BẢN SỬA ĐỔI: Khối này tạo ra một luồng byte thay vì message.
          Đây là cách làm phức tạp hơn và ít được khuyến khích.
          """
          def __init__(self, sdr_uri='ip:192.168.2.1', update_interval=1.0):
              gr.sync_block.__init__(
                  self,
                  name='Pluto Gain Source',
                  in_sig=[],
                  # ĐỊNH NGHĨA ĐẦU RA LÀ BYTE STREAM (màu tím)
                  out_sig=[np.byte]
              )

              self.sdr_uri = sdr_uri
              self.update_interval = update_interval
              self.last_update_time = 0
              
              # Bộ đệm (buffer) nội bộ để chứa các byte đang chờ được gửi đi
              self.pending_bytes = bytearray()

          def work(self, input_items, output_items):
              out_buffer = output_items[0]
              n_out = len(out_buffer) # Số byte có thể ghi ra ở lần gọi này
              
              current_time = time.time()
              
              # 1. Kiểm tra xem đã đến lúc đọc giá trị mới từ SDR chưa
              if (current_time - self.last_update_time) > self.update_interval:
                  self.last_update_time = current_time
                  
                  try:
                      sdr = adi.Pluto(self.sdr_uri)
                      gain_raw = sdr._ctrl.find_channel('voltage0').attrs['hardwaregain'].value
                      gain_str = str(int(float(gain_raw.split()[0])))
                      
                      # Thêm dữ liệu mới (đã mã hóa) vào bộ đệm đang chờ
                      self.pending_bytes.extend(gain_str.encode('utf-8'))
                      del sdr
                  except Exception as e:
                      print(f"[Pluto Gain Stream] Lỗi: {e}")

              # 2. Kiểm tra xem có byte nào đang chờ trong bộ đệm không
              if len(self.pending_bytes) > 0:
                  # Xác định số byte sẽ được ghi ra lần này
                  num_to_write = min(n_out, len(self.pending_bytes))
                  
                  # Sao chép byte từ bộ đệm đang chờ sang bộ đệm đầu ra
                  out_buffer[:num_to_write] = self.pending_bytes[:num_to_write]
                  
                  # Xóa các byte đã được ghi khỏi bộ đệm đang chờ
                  self.pending_bytes = self.pending_bytes[num_to_write:]
                  
                  # Trả về số byte đã thực sự ghi ra
                  return num_to_write
              else:
                  # Nếu không có gì để ghi, trả về 0
                  return 0
    sdr_uri: '''ip:192.168.2.1'''
    update_interval: '1.0'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Mỗi lần tệp này được lưu, GRC sẽ khởi tạo lớp đầu tiên mà nó tìm thấy
      để lấy các cổng và tham số của khối của bạn. Các đối số của __init__
      sẽ là các tham số. Tất cả chúng đều phải có giá trị mặc định!
      """

      import numpy as np
      from gnuradio import gr
      import pmt  # Thư viện cần thiết để xử lý message

      class msg_to_byte_stream(gr.sync_block):
          """
          Khối Python chuyển đổi dữ liệu từ Message Port thành Byte Stream.
          
          - Đầu vào: Một message port tên là 'msg_in' (màu xám).
          - Đầu ra: Một stream port kiểu Byte (màu tím).
          """

          def __init__(self):  # Khối này không cần tham số
              """
              Hàm khởi tạo này sẽ được gọi khi GRC tạo khối.
              """
              gr.sync_block.__init__(
                  self,
                  name='Async to Char',  # Tên sẽ hiển thị trong GRC
                  in_sig=[],  # Không có đầu vào dạng stream
                  out_sig=[np.byte]  # Đầu ra là một luồng byte (màu tím)
              )
              
              # 1. Đăng ký một cổng nhận message có tên là 'msg_in'
              self.message_port_register_in(pmt.intern('msg_in'))
              
              # 2. Thiết lập hàm 'handle_msg' để xử lý bất kỳ message nào đến cổng 'msg_in'
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              
              # 3. Tạo một bộ đệm (buffer) nội bộ để lưu trữ các byte từ message
              #    trước khi chúng được gửi ra stream.
              self.buffer = bytearray()

          def handle_msg(self, msg):
              """
              Hàm này là một "callback", nó sẽ tự động được gọi mỗi khi
              một message được gửi đến cổng 'msg_in'.
              """
              # Kiểm tra xem message có phải là PDU hợp lệ không (dạng pair)
              if pmt.is_pair(msg):
                  # Trích xuất payload (phần thân) của message
                  payload = pmt.cdr(msg)
                  
                  # Kiểm tra xem payload có phải là một vector byte (u8vector) không
                  if pmt.is_u8vector(payload):
                      # Chuyển đổi u8vector thành một đối tượng byte của Python
                      # và thêm vào cuối bộ đệm nội bộ của chúng ta.
                      self.buffer.extend(pmt.u8vector_elements(payload))
              # Nếu message không hợp lệ, nó sẽ bị bỏ qua.

          def work(self, input_items, output_items):
              """
              Hàm work() được scheduler của GNU Radio gọi liên tục để xử lý dữ liệu stream.
              """
              # Lấy bộ đệm đầu ra mà chúng ta có thể ghi vào
              out = output_items[0]
              
              # Số lượng byte tối đa chúng ta có thể ghi trong lần gọi này
              n_out = len(out)
              
              # Kiểm tra xem bộ đệm nội bộ của chúng ta có dữ liệu để gửi đi không
              if len(self.buffer) > 0:
                  # Xác định số byte sẽ được ghi: là số nhỏ hơn giữa
                  # số byte đang chờ và không gian có sẵn trong bộ đệm đầu ra.
                  num_to_write = min(n_out, len(self.buffer))
                  
                  # Sao chép dữ liệu từ bộ đệm nội bộ sang bộ đệm đầu ra
                  out[:num_to_write] = self.buffer[:num_to_write]
                  
                  # Xóa các byte đã được ghi khỏi bộ đệm nội bộ
                  self.buffer = self.buffer[num_to_write:]
                  
                  # Trả về số byte đã được ghi ra
                  return num_to_write
              else:
                  # Nếu không có dữ liệu trong bộ đệm, không ghi gì cả
                  return 0
  states: {}
- name: iio_attr_source_0_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    attribute: '"rssi"'
    channel: '"voltage0"'
    device: '"ad9361-phy"'
    output: 'False'
    samples_per_update: '32'
    type: '1'
    update_interval_ms: '1'
    uri: '"ip:192.168.2.1"'
  states: {}
- name: iio_attr_source_0_0_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    attribute: '"hardwaregain"'
    channel: '"voltage0"'
    device: '"ad9361-phy"'
    output: 'False'
    samples_per_update: '32'
    type: '1'
    update_interval_ms: '1'
    uri: '"ip:192.168.2.1"'
  states: {}
- name: iio_pluto_sink_1
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: center_freq_0
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''hybrid'''
    manual_gain1: attenuation
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '1'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: impl_head
    os_factor: int(samp_rate/bw)
    preamb_len: '8'
    sf: sf
    show_log_port: 'False'
    sync_word: '18'
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    ldro: 'False'
    pay_len: pay_len
    print_header: 'True'
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: cr
    ldro: '0'
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: int(20*2**sf*samp_rate/bw)
    minoutbuf: '10000000'
    preamb_len: '8'
    samp_rate: samp_rate
    sf: sf
    sync_words: '[8,16]'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    length_tag_name: '''packet_len'''
    separator: '''\n'''
    source_type: file_source
    use_length_tag: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '100'
    min: '0'
    name: '"RSSI"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '100'
    min: '0'
    name: '"Hardware Gain"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: ''
    name: '"RSSI Calibration"'
    size: '1024'
    srate: '1000'
    type: float
    ylabel: RSSI
    yunit: '"dB"'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: ''
    name: '"Hardware Gain"'
    size: '1024'
    srate: '1000'
    type: float
    ylabel: Gain
    yunit: '"dB"'
  states: {}

connections:
- [epy_block_1, '0', lora_sdr_whitening_0, '0']
- [epy_block_2, '0', epy_block_0_0, '0']
- [epy_block_3, '0', epy_block_0_1, '0']
- [epy_block_4, '0', epy_block_0_2, '0']
- [iio_attr_source_0_0, '0', qtgui_number_sink_0, '0']
- [iio_attr_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [iio_attr_source_0_0_0, '0', qtgui_number_sink_1, '0']
- [iio_attr_source_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [iio_pluto_source_0, '0', lora_sdr_frame_sync_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_crc_verif_0, '0', epy_block_0, '0']
- [lora_sdr_crc_verif_0, msg, epy_block_4, msg_in]
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', iio_pluto_sink_1, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
