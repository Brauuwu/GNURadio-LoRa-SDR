options:
  parameters:
    author: Tapparel Joachim@EPFL,TCL
    generate_options: no_gui
    id: tx_rx_functionality_check
    output_language: python
  states: {}

blocks:
- name: SNRdB
  id: variable
  parameters:
    value: '-8.75'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '868000000'
  states: {}
- name: clk_offset
  id: variable
  parameters:
    comment: Clock offset in ppm
    value: '0'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '4'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '255'
  states: {}
- name: preamb_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw*4
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '0x12'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(2**sf*samp_rate/bw*10.1)
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/brau/LoRaSDR/Text_Output/text.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.intern("Hello: 0")'
    period: '1000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: 1.0+clk_offset*1e-6
    freq_offset: center_freq*clk_offset*1e-6/samp_rate
    minoutbuf: int((2**sf+2)*samp_rate/bw)
    noise_voltage: 10**(-SNRdB/20)
    seed: '0'
    taps: 1.0 + 0.0j
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import paho.mqtt.client as mqtt
      import threading
      import queue


      class mqtt_publisher(gr.sync_block):
          """
          MQTT Publisher Block (Local Broker)
          - Nhận byte stream từ GNU Radio
          - Gom thành chuỗi (theo '\n') và publish lên MQTT
          """

          def __init__(self, host="127.0.0.1", port=1883,
                       username=None, password=None,
                       topic="gnuradio/output"):
              gr.sync_block.__init__(
                  self,
                  name="MQTT Publisher",
                  in_sig=[np.uint8],
                  out_sig=None
              )

              self.host = host
              self.port = port
              self.username = username
              self.password = password
              self.topic = topic

              self.buffer = bytearray()

              # MQTT client
              self.client = mqtt.Client()
              if self.username and self.password:
                  self.client.username_pw_set(self.username, self.password)

              self.client.on_connect = self.on_connect

              # Thread MQTT
              self.mqtt_thread = threading.Thread(target=self._mqtt_loop, daemon=True)
              self.mqtt_thread.start()

          def on_connect(self, client, userdata, flags, rc):
              if rc == 0:
                  print("[MQTT] Publisher connected to local broker")
              else:
                  print("[MQTT] Publisher failed, rc=", rc)

          def _mqtt_loop(self):
              self.client.connect(self.host, self.port, keepalive=60)
              self.client.loop_forever()

          def work(self, input_items, output_items):
              data = input_items[0]
              
              if len(data) > 0:
                  msg = bytes(data).decode("utf-8", errors="ignore")
                  if msg.strip():
                      self.client.publish(self.topic, msg)
                      print(f"[MQTT] Published: {msg}")

              return len(data)
    host: '''127.0.0.1'''
    password: '''1'''
    port: '1883'
    topic: '''data/output'''
    username: '''root'''
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import paho.mqtt.client as mqtt
      import threading
      import queue

      class mqtt_subscriber(gr.sync_block):
          """
          MQTT Subscriber Block (Local Broker)
          - Nhận message từ Node-RED hoặc client MQTT khác
          - Segment payload thành subpayload (<= max_len, thêm '\n')
          - Xuất ra stream GNU Radio (byte)
          """

          def __init__(self, host="127.0.0.1", port=1883,
                       username=None, password=None,
                       topic="gnuradio/input", buf_len=1024, max_len=255):
              gr.sync_block.__init__(
                  self,
                  name="MQTT Subscriber",
                  in_sig=None,
                  out_sig=[np.uint8]
              )

              self.host = host
              self.port = port
              self.username = username
              self.password = password
              self.topic = topic
              self.buf_len = buf_len
              self.max_len = max_len

              self.queue = queue.Queue()

              # MQTT client
              self.client = mqtt.Client()
              if self.username and self.password:
                  self.client.username_pw_set(self.username, self.password)

              self.client.on_connect = self.on_connect
              self.client.on_message = self.on_message

              # Thread MQTT
              self.mqtt_thread = threading.Thread(target=self._mqtt_loop, daemon=True)
              self.mqtt_thread.start()

          def on_connect(self, client, userdata, flags, rc):
              if rc == 0:
                  print("[MQTT] Connected to local broker")
                  client.subscribe(self.topic)
              else:
                  print("[MQTT] Failed to connect, rc=", rc)

          def on_message(self, client, userdata, msg):
              text = msg.payload.decode("utf-8")
              print(f"[MQTT] Received: {text}")

              # Segmenter
              data = text.encode("utf-8")
              for i in range(0, len(data), self.max_len):
                  sub = data[i:i + self.max_len]
                  if len(sub) < 2:
                      sub = sub + b' '
                  sub = sub + b'\n'
                  arr = np.frombuffer(sub, dtype=np.uint8)
                  for b in arr:
                      self.queue.put(b)

          def _mqtt_loop(self):
              self.client.connect(self.host, self.port, keepalive=60)
              self.client.loop_forever()

          def work(self, input_items, output_items):
              out = output_items[0]

              i = 0
              while not self.queue.empty() and i < len(out):
                  out[i] = self.queue.get()
                  i += 1

              return i
    buf_len: '1024'
    host: '''127.0.0.1'''
    max_len: '255'
    password: '''1'''
    port: '1883'
    topic: '''data/input'''
    username: '''root'''
  states: {state: disabled}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_data_source_0
  id: lora_sdr_data_source
  parameters:
    n_frames: '490'
    pay_len: '255'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: impl_head
    os_factor: int(samp_rate/bw)
    preamb_len: preamb_len
    sf: sf
    show_log_port: 'False'
    sync_word: sync_word
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: pay_len
    print_header: 'True'
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: bw
    cr: cr
    ldro: '2'
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: int(20*2**sf*samp_rate/bw)
    minoutbuf: '10000000'
    preamb_len: preamb_len
    samp_rate: int(samp_rate)
    sf: sf
    sync_words: sync_word
  states: {}
- name: lora_sdr_payload_id_inc_0
  id: lora_sdr_payload_id_inc
  parameters:
    separator: ':'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    length_tag_name: '''packet_len'''
    separator: '''\n'''
    source_type: message_strobe
    use_length_tag: 'False'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [blocks_delay_0, '0', blocks_throttle2_0, '0']
- [blocks_message_strobe_0, strobe, lora_sdr_data_source_0, trigg]
- [blocks_message_strobe_0, strobe, lora_sdr_payload_id_inc_0, msg_in]
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', lora_sdr_frame_sync_0, '0']
- [channels_channel_model_0, '0', qtgui_const_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_0, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_crc_verif_0, '0', blocks_file_sink_0, '0']
- [lora_sdr_crc_verif_0, '0', epy_block_0, '0']
- [lora_sdr_crc_verif_0, msg, blocks_message_debug_0, print]
- [lora_sdr_data_source_0, msg, blocks_message_debug_0_0, print]
- [lora_sdr_data_source_0, msg, lora_sdr_whitening_0, msg]
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', blocks_delay_0, '0']
- [lora_sdr_payload_id_inc_0, msg_out, blocks_message_strobe_0, set_msg]
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
